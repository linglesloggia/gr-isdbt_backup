options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: full_transceiver_isdbt
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: 0.0022097087*2
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: length_a
  id: variable
  parameters:
    value: '4'
  states: {}
- name: length_b
  id: variable
  parameters:
    value: '2'
  states: {}
- name: length_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: segments_a
  id: variable
  parameters:
    value: '13'
  states: {}
- name: segments_b
  id: variable
  parameters:
    value: '0'
  states: {}
- name: segments_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: samp_rate/1.0
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lingles/fing/gr-isdbt/layer_a_out.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lingles/fing/gr-isdbt/layer_a.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: bb_gain
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    comment: See sec. 3.9.2 of the standard.
    num_items: '2'
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: throttle_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: total_carriers
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: total_carriers
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: int(total_carriers*guard)
    input_size: total_carriers
    tagname: ''
  states: {}
- name: dtv_dvbt_inner_coder_0_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C2_3
    constellation: 64qam
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_viterbi_decoder_0_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '204'
    code_rate: C2_3
    constellation: 64qam
    hierarchy: alpha4
    type: b
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: total_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(total_carriers)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: isdbt_bit_deinterleaver_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: '13'
  states: {}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_interleaver_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: '13'
    rate: '1'
  states: {}
- name: isdbt_carrier_modulation_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: '13'
  states: {}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_dispersal_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: '13'
    rate: '1'
  states: {}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '3'
    oneseg: 'False'
  states: {}
- name: isdbt_frequency_interleaver_0
  id: isdbt_frequency_interleaver
  parameters:
    mode: '3'
    oneseg: 'False'
  states: {}
- name: isdbt_hierarchical_combinator_0
  id: isdbt_hierarchical_combinator
  parameters:
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'True'
    mode: '3'
  states: {}
- name: isdbt_pilot_signals_0
  id: isdbt_pilot_signals
  parameters:
    mode: '3'
  states: {}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '64'
    constellation_size_B: '64'
    constellation_size_C: '64'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '4'
    length_B: '2'
    length_C: '0'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_time_interleaver_0
  id: isdbt_time_interleaver
  parameters:
    length_A: '4'
    length_B: '2'
    length_C: '0'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'True'
  states: {}
- name: isdbt_tmcc_encoder_0
  id: isdbt_tmcc_encoder
  parameters:
    conv_code_A: '1'
    conv_code_B: '2'
    conv_code_C: '0'
    int_length_A: '4'
    int_length_B: '2'
    int_length_C: '0'
    mod_scheme_A: '64'
    mod_scheme_B: '64'
    mod_scheme_C: '64'
    mode: '3'
    nsegs_A: '13'
    nsegs_B: '0'
    nsegs_C: '0'
    one_seg_present: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,1,1,2)
    name: '"Constellation post pilot_signals"'
    size: '8192'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,1,1,2)
    name: '"Received Constellation"'
    size: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,0,2,1)
    name: '"pilot_signals TimeSink"'
    nconnections: '2'
    size: 4*total_carriers
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_skiphead_0_0, '0', isdbt_pilot_signals_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_throttle_0_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_0_1, '0', qtgui_time_sink_x_2, '1']
- [blocks_vector_to_stream_0_0_2, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', isdbt_carrier_modulation_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_xx_0, '0']
- [dtv_dvbt_inner_coder_0_0, '0', blocks_vector_to_stream_0_1, '0']
- [dtv_dvbt_reed_solomon_dec_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', isdbt_energy_dispersal_0, '0']
- [dtv_dvbt_viterbi_decoder_0_0, '0', isdbt_byte_deinterleaver_0, '0']
- [fft_vxx_1, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [isdbt_bit_deinterleaver_0, '0', dtv_dvbt_viterbi_decoder_0_0, '0']
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_interleaver_0, '0', dtv_dvbt_inner_coder_0_0, '0']
- [isdbt_carrier_modulation_0, '0', isdbt_hierarchical_combinator_0, '0']
- [isdbt_energy_descrambler_0, '0', dtv_dvbt_reed_solomon_dec_0_0, '0']
- [isdbt_energy_dispersal_0, '0', isdbt_byte_interleaver_0, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_frequency_interleaver_0, '0', blocks_skiphead_0_0, '0']
- [isdbt_hierarchical_combinator_0, '0', isdbt_time_interleaver_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0_0_2, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_pilot_signals_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_pilot_signals_0, '0', isdbt_tmcc_encoder_0, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_time_interleaver_0, '0', isdbt_frequency_interleaver_0, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [isdbt_tmcc_encoder_0, '0', blocks_vector_to_stream_0_0_1, '0']
- [isdbt_tmcc_encoder_0, '0', fft_vxx_1, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']

metadata:
  file_format: 1
