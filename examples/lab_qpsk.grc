options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: qpsk_transceiver_isdbt
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: alfa
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: d
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Muestra
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: samp_per_sym-1
    value: '0'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Error de muestreo (% samp_rate)
    orient: Qt.Horizontal
    start: 1-1e-4
    step: '1e-6'
    stop: 1+1e-4
    value: '1'
  states: {}
- name: freq_error
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Error en frecuencia (% samp_rate)
    orient: Qt.Horizontal
    start: '-1'
    step: '1e-5'
    stop: '1'
    value: '0'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: iip3
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Distorsion de orden tres (IIP3, dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: len_sym_srrc
  id: variable
  parameters:
    value: '15'
  states: {}
- name: length_a
  id: variable
  parameters:
    value: '4'
  states: {}
- name: length_b
  id: variable
  parameters:
    value: '2'
  states: {}
- name: length_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Ruido en el canal
    orient: Qt.Horizontal
    start: '1e-9'
    step: '1e-6'
    stop: '0.5'
    value: '1e-9'
  states: {}
- name: phase_noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Ruido de fase
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '5'
    value: '0'
  states: {}
- name: pulso_srrc
  id: variable
  parameters:
    value: firdes.root_raised_cosine(np.sqrt(samp_per_sym),samp_rate,samp_rate/samp_per_sym,alfa,len_sym_srrc*samp_per_sym)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate*samp_per_sym
  states: {}
- name: samp_rate_estandar
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: segments_a
  id: variable
  parameters:
    value: '13'
  states: {}
- name: segments_b
  id: variable
  parameters:
    value: '0'
  states: {}
- name: segments_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate_estandar*data_carriers/((1+guard)*total_carriers)
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: samp_rate/1.0
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: d
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: result_layer_b.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lingles/fing/gr-isdbt/layer_a.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_sym
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '4992'
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: See sec. 3.9.2 of the standard.
    num_items: '2'
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: int(np.floor(len(pulso_srrc)/samp_per_sym/2.0))+int(np.floor(len(pulso_srrc)/samp_per_sym/2.0))
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: throttle_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[gr.tag_utils.python_to_tag( [0, pmt.intern("frame_begin"), pmt.from_long(0), "yo"])]'
    type: complex
    vector: '[0]*204*data_carriers'
    vlen: data_carriers
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: freq_error
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: channels_distortion_3_gen_0
  id: channels_distortion_3_gen
  parameters:
    beta: '-0.11/10**(iip3/10.0)'
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.01'
    noise_mag: phase_noise
  states: {}
- name: dtv_dvbt_inner_coder_0_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C1_2
    constellation: qpsk
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '204'
    code_rate: C1_2
    constellation: qpsk
    hierarchy: alpha4
    type: b
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pulso_srrc
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: isdbt_38_reed_solomon_dec_isdbt_0
  id: isdbt_38_reed_solomon_dec_isdbt
  parameters: {}
  states: {state: disabled}
- name: isdbt_38_viterbi_decoder_0
  id: isdbt_38_viterbi_decoder
  parameters:
    constellation_size: '4'
    rate: '0'
  states: {state: disabled}
- name: isdbt_bit_deinterleaver_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '4'
    mode: '3'
    segments: '13'
  states: {}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_interleaver_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '4'
    mode: '3'
    nsegments: '13'
    rate: '0'
  states: {}
- name: isdbt_carrier_modulation_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '4'
    mode: '3'
    segments: '13'
  states: {}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_dispersal_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '4'
    mode: '3'
    nsegments: '13'
    rate: '0'
  states: {}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '3'
    oneseg: 'False'
  states: {}
- name: isdbt_frequency_interleaver_0
  id: isdbt_frequency_interleaver
  parameters:
    mode: '3'
    oneseg: 'False'
  states: {}
- name: isdbt_hierarchical_combinator_0
  id: isdbt_hierarchical_combinator
  parameters:
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {state: disabled}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '4'
    constellation_size_B: '4'
    constellation_size_C: '4'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '2'
    length_B: '0'
    length_C: '0'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: isdbt_time_interleaver_0
  id: isdbt_time_interleaver
  parameters:
    length_A: '2'
    length_B: '0'
    length_C: '0'
    mode: '3'
    segments_A: '13'
    segments_B: '0'
    segments_C: '0'
  states: {}
- name: pfb_interpolator_ccf_0
  id: pfb_interpolator_ccf
  parameters:
    atten: '100'
    interp: samp_per_sym
    taps: pulso_srrc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@0
    marker1: '-1'
    size: '200'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 7,0,1,1
    name: '"Reed-Solomon BER"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 6,0,1,1
    name: '"Viterbi BER"'
    type: float
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,8,4
    label0: Diagrama IQ
    label1: Espectro en recepcion
    label2: Constelacion en recepcion
    num_tabs: '3'
  states: {}

connections:
- [blocks_add_xx_0_0_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [blocks_delay_0_0_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_delay_0_0_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_skiphead_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_skiphead_0, '0', blocks_vector_to_stream_2, '0']
- [blocks_skiphead_1, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_add_xx_0_0_0, '1']
- [blocks_throttle_0_0, '0', channels_phase_noise_gen_0, '0']
- [blocks_throttle_0_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0_1, '0', isdbt_carrier_modulation_0, '0']
- [blocks_vector_to_stream_2, '0', pfb_interpolator_ccf_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0_0_0_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_distortion_3_gen_0, '0', channels_channel_model_0, '0']
- [channels_phase_noise_gen_0, '0', channels_distortion_3_gen_0, '0']
- [dtv_dvbt_inner_coder_0_0, '0', blocks_vector_to_stream_0_1, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', isdbt_energy_dispersal_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', isdbt_byte_deinterleaver_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0_0_0, '0']
- [isdbt_38_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [isdbt_38_reed_solomon_dec_isdbt_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_38_viterbi_decoder_0, '0', blocks_nlog10_ff_0_0, '0']
- [isdbt_bit_deinterleaver_0, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_interleaver_0, '0', dtv_dvbt_inner_coder_0_0, '0']
- [isdbt_carrier_modulation_0, '0', isdbt_hierarchical_combinator_0, '0']
- [isdbt_energy_descrambler_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [isdbt_energy_descrambler_0, '0', isdbt_reed_solomon_dec_isdbt_0, '0']
- [isdbt_energy_dispersal_0, '0', isdbt_byte_interleaver_0, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_frequency_interleaver_0, '0', blocks_skiphead_0, '0']
- [isdbt_hierarchical_combinator_0, '0', isdbt_time_interleaver_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_time_interleaver_0, '0', isdbt_frequency_interleaver_0, '0']
- [pfb_interpolator_ccf_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
